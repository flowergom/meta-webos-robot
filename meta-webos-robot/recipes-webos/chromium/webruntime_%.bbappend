# Copyright (c) 2021 LG Electronics, Inc.

EXTENDPRAUTO_append = "robot1"

PACKAGECONFIG_remove = "gstreamer umediaserver neva-media gav neva-webrtc"
